File: Hardware/LightPanel/LightPanel.kicad_sch (KiCad schematic)
At the start: 21 parts, among them J1 BoardToBoard

Commit message: Fix ERC
Other:
- title: (none) -> Light Panel
